DEPENDS = "ocaml-cross ocaml-ocamlbuild ocaml-camlp4"
require ocaml-findlib.inc
inherit cross
