DEPENDS = "ocaml-native ocaml-ocamlbuild-native ocaml-camlp4-native m4-native"

inherit native ocaml
require ocaml-findlib.inc
